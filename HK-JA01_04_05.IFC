Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-JA.IFC
Time: 2022-01-04T05:41:58
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: HK-JA
In: Default Storey
PredefinedType: ELEMENT; Material: 0
